Commit message: smaller platform

File: urdf/turbine.xacro (robot description, xacro)
@@ -40,5 +40,5 @@
         <parent link="${name}/base_link"/>
         <child link="${name}/pole"/>
-        <origin xyz="-13.5 0 0"/>
+        <origin xyz="${-13.5/1.5} 0 0"/>
     </joint>
 </xacro:if>
